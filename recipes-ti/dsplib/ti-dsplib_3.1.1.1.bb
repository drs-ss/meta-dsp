require ti-dsplib.inc

# This isn't a license, but they don't provide one...
LIC_FILES_CHKSUM = "file://README.txt;md5=840945804c389f6463a8d4b6d2d454ac"

PE = "1"
PV = "3_1_1_1"
PVwithdots = "3.1.1.1"

SRC_URI[dsplibbin.md5sum] = "9a6a94a48d2098174ec2d31de399ef34"
SRC_URI[dsplibbin.sha256sum] = "764492495b10e4b85980c0136a10d267a341ffdf3596d72291e32793874fed82"

