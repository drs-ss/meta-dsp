require ti-iqmathlib.inc

# This isn't a license, but they don't provide one...
LIC_FILES_CHKSUM = "file://README.txt;md5=f95320298cc1b91eda0ff31c858b8835"

PE = "1"
PV = "2_01_04_00"
PVwithdots = "2.1.4.0"

SRC_URI[iqmathlibbin.md5sum] = "541fbb81627f0cc6c7eaa357dfaf7b24"
SRC_URI[iqmathlibbin.sha256sum] = "1b1607cd2a12ed81ee3a3613ca9472986242ddf4265858af9da2f3a4d738db2f"

